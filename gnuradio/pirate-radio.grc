options:
  parameters:
    generate_options: qt_gui
    id: pirate_radio
    output_language: python
    title: Pirate Radio
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48_000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '480_000'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 102.2e6
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: '2_000_000'
  states: {}
- name: transmit_status_label
  id: variable_qtgui_label
  parameters:
    label: Transmitting at
    type: string
    value: str(rf_freq/1e6) + " MHz"
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: quad_rate
    fh: '-1.0'
    max_dev: '75_000'
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio/example_1mb.wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: quad_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: quad_rate
    interp: rf_rate
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: rf_freq
    samp_rate: rf_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
